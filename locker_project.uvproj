# Keil uVision project locker_project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: locker_project
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s delay.c delay.h types.h defines.h lcd.c lcd.h rtc.c rtc.h uart.c uart.h buzzer.c buzzer.h keypad.c keypad.h bluetooth.c bluetooth.h menu.c menu.h security.c security.h motor.c motor.h main.c eeprom.c eeprom.h
